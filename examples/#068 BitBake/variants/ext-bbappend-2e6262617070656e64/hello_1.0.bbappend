python do_build:append() {
    bb.plain("Hello, World!")
}
