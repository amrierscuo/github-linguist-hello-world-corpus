SUMMARY = "Corpus greeting recipe"
LICENSE = "CLOSED"
python do_build() {
    pass
}
addtask build
