# Minimal base class for this standalone illustrative BitBake layer.
# No shared tasks are defined here; the greeting recipe declares its own task.
